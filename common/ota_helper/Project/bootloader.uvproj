# Keil uVision project bootloader.uvproj, settings and files
target Code (6160000::V6.16::ARMCLANG)
  device: OB90A64M1 On-Bright
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FDFF) IROM2(0x0FE00-0x0FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: bootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: BUILD_BOOTLOADER
  c include: ..\Device;..\User\include;..\..\common\CMSIS\5.4.0;..\..\common\Device;..\..\common\Driver\include;..\..\common\User\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400
  memory RVCT5: ROM 0x100200 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Device\bootloader.sct
  link misc: --diag_suppress=L6329W --symdefs=..\..\common\boot_symbol.obj --entry=boot_main --no_startup
  group Device
    ../Device/: vector_table.c bootloader_startup.s
    ../../common/Device/: system_OB90A64M1.c user_option_OB90A64M1.c
  group Driver
    ../../common/Driver/: flash_util.c fmc_flash.c boot_spi_flash.c
  group User
    ../User/: main.c app_entry.c
    ../../common/User/: ota_file.c ota_info.c
