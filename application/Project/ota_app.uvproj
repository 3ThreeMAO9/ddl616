# Keil uVision project ota_app.uvproj, settings and files
target 39140 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: OB90A64M1B On-Bright
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x0FDFF) IROM2(0x0FE00-0x0FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ota_app +hex
  AfterMake: .\packer2.exe ..\Build\Objects\ota_app.hex
  AfterMake: .\OTA_Process.exe
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CLIENT_ITEM_SN=39140,PROJECT_NUMBER=140,CONFIG_SEL=39
  c misc: --locale=english
  c include: ..\..\common\Device;..\chip\OB90A64M1\Library;..\config;..\hal;.\Source_Code\device;..\drive\i2c_software;..\drive\utils;..\drive\key;..\3rd\multi_button;..\3rd\multi_button\examples;..\drive\system_timer;..\drive\ob_log;..\config\board;..\config\item;..\config\item\item_info;..\task\task_key;..\bsp\bsp_key;..\protocol\handler;..\protocol;..\drive\led;..\bsp\bsp_led;..\task\task_led;..\3rd\ringbuffer;..\3rd\rt-thread;..\task\task_uart;..\drive\uart_queue;..\bsp\bsp_uart;..\module\module_uart;..\bsp\bsp_nfc;..\drive\nfc;..\drive\nfc\FM17622;..\task\task_nfc;..\bsp\bsp_fingerprint;..\drive\fingerprint;..\module\module_fp;..\task\task_fingerprint;..\bsp\bsp_face;..\drive\face;..\drive\face\face_st;..\module\module_face;..\task\task_face;..\drive\soft_uart;..\drive\soft_uart\simu_uart;..\drive\soft_uart\soft_uart_finger;..\drive\soft_uart\soft_uart_log;..\drive\radar;..\drive\radar\iic_radar;..\task\task_radar;..\bsp\bsp_radar;..\module\module_radar;..\task\task_system_time;..\bsp\bsp_system_time;..\bsp\bsp_sleep;..\drive\sleep;..\task\task_sleep;..\task\task_qp_fsm;..\bsp\bsp_qp_fsm;..\fsm\event;..\fsm\qp_frame;..\fsm\state;..\drive\key\key_board;..\drive\key\key_board\GTX314L;..\drive\key\tamper_key;..\bsp\bsp_flash;..\drive\flash;..\task\task_flash;..\drive\dual_sector;..\drive\parameter;..\task\task_protocol;..\drive\spi_software;..\app\protocol_func_card;..\..\common\CMSIS\5.4.0;..\..\common\Library;..\..\common\ota_helper;..\..\common\Device;..\drive\radar\iic_radar\include;..\drive\radar\io_radar\include;..\drive\lock_uart;..\..\common\encrypt;..\3rd\sfud\src;..\3rd\sfud\inc;..\bsp\bsp_sfud;..\module\module_spi_flash;..\module\module_flash_data;..\app\parameter;..\app\user;..\bsp\bsp_player;..\module\module_player;..\task\task_player;..\bsp\bsp_hmi;..\module\module_hmi;..\task\task_hmi;..\bsp\bsp_motor;..\drive\motor;..\task\task_motor;..\module\module_motor;..\fsm\menu;..\bsp\bsp_battery;..\module\module_battery;..\task\task_battery;..\module\module_lock_log
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfe00
  memory RVCT5: ROM 0xfe00 size 0x200
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Start_Up
    ../../common/: boot_symbol.obj
    ../../common/Device/: system_OB90A64M1.c startup_OB90A64M1.s
  group Source Code
    ./Source_Code/: main.c
  group Library
    ../chip/OB90A64M1/Library/: adc.c gpio.c pwm.c rtc.c spi.c timer16.c timer32.c uart.c wdt.c
    ../../common/Library/: fmc.c
  group 3rd
    ../3rd/multi_button/: multi_button.c
    ../3rd/ringbuffer/: ringbuffer.c
    ../3rd/sfud/src/: sfud.c sfud_sfdp.c
  group config
    ../config/item/: item_config.c
  group device
    ./Source_Code/device/: delay.c lvr.c
  group debug
    ../drive/ob_log/: ob_log.c ob_log_port.c
  group hal
    ../hal/: hal_fmc.c hal_gpio.c hal_iic.c hal_spi.c hal_spi_software.c hal_timer.c hal_uart.c hal_wdt.c hal_rtc.c hal_flash.c hal_pwm.c hal_adc.c
  group bsp
    ../bsp/bsp_fingerprint/: bsp_fingerprint.c
    ../bsp/bsp_key/: bsp_key.c
    ../bsp/bsp_nfc/: bsp_nfc.c
    ../bsp/bsp_qp_fsm/: bsp_qp_fsm.c
    ../bsp/bsp_sleep/: bsp_sleep.c
    ../bsp/bsp_system_time/: bsp_system_time.c
    ../bsp/bsp_uart/: bsp_uart.c
    ../bsp/bsp_sfud/: bsp_sfud_port.c
    ../bsp/bsp_player/: bsp_player.c
    ../bsp/bsp_hmi/: bsp_hmi.c
    ../bsp/bsp_motor/: bsp_motor.c
    ../bsp/bsp_battery/: bsp_battery.c
  group fsm
    ../fsm/qp_frame/: qp_fsm.c qp_port.c
  group fsm/event
    ../fsm/event/: event.c event_queue.c key_event.c
  group fsm/state
    ../fsm/state/: fsm_state_idle.c fsm_state_power_on.c fsm_state_sleep.c fsm_state_result.c fsm_state_verify_admin.c fsm_state_reset.c fsm_state_low_power_system_lock.c fsm_state_system_lock.c
  group fsm/menu
    ../fsm/menu/: fsm_menu_admin.c fsm_menu_modfiy_admin_pin.c fsm_menu_add_normal_user.c fsm_menu_language_settings.c fsm_menu_linked_unlock.c fsm_menu_user_settings.c fsm_menu_system_settings.c fsm_menu_repeat_input_code.c fsm_menu_create_linked_unlock.c fsm_menu_join_linked_unlock.c
  group app
    ../app/protocol_func_card/: protocol_func_card.c
    ../app/parameter/: parameter.c
    ../app/user/: user.c
  group driver
    ../drive/key/: key.c
    ../drive/i2c_software/: i2c_software.c
    ../drive/utils/: utils.c validation.c timestamp.c
    ../drive/uart_queue/: uart_queue.c
    ../drive/fingerprint/: fingerprint.c
    ../drive/system_timer/: system_timer.c
    ../drive/sleep/: sleep.c
    ../drive/key/key_board/: key_board.c
    ../drive/key/key_board/GTX314L/: gtx314l.c
    ../drive/key/tamper_key/: tamper_key.c
    ../drive/flash/: flash.c flash_drive.c
    ../drive/dual_sector/: dual_sector.c
    ../drive/spi_software/: spi_software.c
    ../drive/soft_uart/simu_uart/: simu_uart.c
    ../drive/led/: led.c
    ../drive/motor/: motor.c
  group driver/nfc
    ../drive/nfc/FM17622/: DEVICE_CFG.c FM17622.c MIFARE.c READER_API.c
    ../drive/nfc/: NFC_API.c
  group module
    ../module/module_uart/: module_uart.c
    ../module/module_fp/: fingerprint_api.c
    ../module/module_spi_flash/: module_spi_flash.c
    ../module/module_flash_data/: flash_data.c
    ../module/module_player/: module_player.c
    ../module/module_hmi/: module_hmi.c
    ../module/module_motor/: module_motor.c
    ../module/module_battery/: module_battery.c
    ../module/module_lock_log/: lock_log.c lock_log_flash.c
  group protocol
    ../protocol/: msg_protocol.c uart_protocol.c
    ../protocol/handler/: uart_protocol_heart.c
  group task
    ../task/task_fingerprint/: task_fingerprint.c
    ../task/task_key/: task_key.c
    ../task/task_nfc/: task_nfc.c
    ../task/task_protocol/: task_protocol.c
    ../task/task_qp_fsm/: task_qp_fsm.c
    ../task/task_sleep/: task_sleep.c
    ../task/task_system_time/: task_system_time.c
    ../task/task_uart/: task_uart.c
    ../task/task_player/: task_player.c
    ../task/task_hmi/: task_hmi.c
    ../task/task_motor/: task_motor.c
    ../task/task_battery/: task_battery.c
  group ota_helper
    ../../common/ota_helper/: ota_helper.c
  group encrypt
    ../../common/encrypt/: encrypt.c
